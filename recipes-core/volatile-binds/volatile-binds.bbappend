VOLATILE_BINDS = "\
	/var/volatile/cache /var/cache\n\
	/var/volatile/spool /var/spool\n\
"
