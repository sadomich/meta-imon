PACKAGECONFIG:append = " readline"